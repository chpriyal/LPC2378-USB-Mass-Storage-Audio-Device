# Keil uVision project Memory.uvproj, settings and files
target LPC23xx Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Memory
  c flags: Optim=4 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ./: SWI_Table.s LPC2300.s
  group Configuration
    ./: File_Config.c usb_config.c RTX_Conf_LPC23xx.c
  group Drivers
    ./: LED.c KBD.c Serial.c LCD_4bit.c MCI_LPC23xx.c UART_LPC23xx.c
  group File System
    ./: Retarget.c
    C:/Keil_v5/ARM/RV31/LIB/: FS_ARM_L.lib
  group USB
    C:/Keil_v5/ARM/RV31/LIB/: USB_ARM_L.lib
    ./: usbd_LPC23xx.c usbd_user_adc.c usbd_user_cdc_acm.c usbd_user_msc.c
  group Main Code
    ./: Memory.c
  group Documentation
    ./: Abstract.txt
